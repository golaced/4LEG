# Keil uVision project STM32_DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_DEMO +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\Libraries\src;..\Libraries\inc;..\Startup;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: stm32f10x_it.c main.c delay.c sys.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
